Commit message: fix: changes

File: urdfs/ur5/ur5.urdf (robot description, URDF)
Before this commit: robot ur5, 12 links, 11 joints
Joints:
- joint base_joint: parent virtual_y_link -> world
